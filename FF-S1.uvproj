# Keil uVision project FF-S1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: FF-S1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 c8051F020.h c8051F020_SFR16.h FF-S1.c FF-S1_Config.H FF-S1_Config_.c FF-S1_Divers.C FF-S1_Divers.H
